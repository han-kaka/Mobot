# Keil uVision project LED.uvprojx, settings and files
target target (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ESW3120NQ Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: out +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_ASSERT
  c misc: --c99
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include\ES32W3120;..\..\..\..\..\..\Drivers\ALD\ES32W3120\Include;..\Src;..\Inc;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Interface;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\lib\Include;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Profile\led;..\..\..\..\..\..\Middlewares\Third_Party\RTT;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Log\Include;..\..\..\..\..\..\Drivers\MD\ES32W3120\Include;..\app;..\bsp;..\task
  library: MicroLIB
  memory RVCT4: ROM 0x64000 size 0x1c000
  memory RVCT9: RAM 0x20009d70 size 0xa000
  group app
    ../Inc/: sdk_conf.h esapp.h
    ../Src/: esapp.c main.c global.h irq.c
    ../app/: app_common.h app_common.c
  group bsp
    ../bsp/: bsp_system.c bsp_system.h bsp_common.h bsp_common.c bsp_mp6050.c bsp_mp6050.h bsp_dx_bt24_t.c bsp_dx_bt24_t.h
  group task
    ../task/: task_bluetooth.c task_bluetooth.h task_common.c task_common.h task_communicate.c task_communicate.h task_control.c task_control.h task_measure.c task_measure.h task_mem_read.c task_mem_read.h task_mem_write.c task_mem_write.h task_other.c task_other.h task_safeguard.c task_safeguard.h
  group profile
    ../../../../../../Middlewares/EastSoft/BLE5.0/Profile/led/: esprf_led.c esprf_led.h
  group ald
    ../../../../../../Drivers/ALD/ES32W3120/Source/: ald_gpio.c
  group md
    ../../../../../../Drivers/MD/ES32W3120/Source/: md_gpio.c md_uart.c md_cmu.c md_utils.c md_i2c.c md_dma.c
    ../../../../../../Drivers/MD/ES32W3120/Include/: md_utils.h md_i2c.h md_dma.h
  group lib
    ../../../../../../Middlewares/EastSoft/BLE5.0/Lib/Source/: lib.c lib_conf.c lib_adv.c lib_advdata.c lib_scan.c lib_init.c lib_db_discovery.c
    ../../../../../../Middlewares/EastSoft/BLE5.0/Lib/Include/: lib.h lib_conf.h lib_adv.h lib_advdata.h lib_list.h
  group ble_interface
    ../../../../../../Middlewares/EastSoft/BLE5.0/Interface/: esble.h esble_att.h esble_comm.h esble_def.h esble_error.h esble_gapc.h esble_gapm.h esble_gattc.h esble_gattm.h
  group startup
    ../../../../../../Drivers/CMSIS/Device/EastSoft/ES32W3120/Startup/keil/: startup_es32w3120.s
  group eslog
    ../../../../../../Middlewares/EastSoft/BLE5.0/Log/Source/: eslog_init.c eslog_printf_format.c eslog_uart.c
  group RTT
    ../../../../../../Middlewares/Third_Party/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
target ble_stack (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ESW3120NQ Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.8
  cpu: as above
  output: esble_firmware_v1.00.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_ASSERT
  c misc: --c99
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\EastSoft\ES32W3120\Include\ES32W3120;..\..\..\..\..\..\Drivers\ALD\ES32W3120\Include;..\Src;..\Inc;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Interface;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\lib\Include;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Profile\led;..\..\..\..\..\..\Middlewares\Third_Party\RTT;..\..\..\..\..\..\Middlewares\EastSoft\BLE5.0\Log\Include;..\..\..\..\..\..\Drivers\MD\ES32W3120\Include
  library: MicroLIB
  memory RVCT4: ROM 0x64000 size 0x1c000
  memory RVCT9: RAM 0x20009d70 size 0xa000
